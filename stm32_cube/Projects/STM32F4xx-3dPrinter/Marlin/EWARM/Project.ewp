# IAR project Project.ewp, settings and files
configuration Marlin (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; STM_3DPRINT; MARLIN; NO_SD_WIDE_BUS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Drivers\BSP\STM32F4xx-3dPrinter; ..\..\..\..\Drivers\BSP\MotorControl; ..\..\..\..\Drivers\BSP\Components\l6474; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Middlewares\Third_Party\Marlin; ..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demonstrations/EWARM
    ./: startup_stm32f401xe.s
  group Demonstrations/User
    ../Src/: clock_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/l6474
    ../../../../Drivers/BSP/Components/l6474/: l6474.c
  group Drivers/BSP/MotorControl
    ../../../../Drivers/BSP/MotorControl/: motorcontrol.c
  group Drivers/BSP/STM32F4xx-3dPrinter
    ../../../../Drivers/BSP/STM32F4xx-3dPrinter/: stm32f4xx_3dprinter_adc.c stm32f4xx_3dprinter_misc.c stm32f4xx_3dprinter_motor.c stm32f4xx_3dprinter_sd.c stm32f4xx_3dprinter_uart.c stm32f4xx_3dprinter_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/Marlin
    ../../../../Middlewares/Third_Party/Marlin/: BlinkM.cpp cardreader.cpp ConfigurationStore.cpp digipot_mcp4451.cpp Marlin_main.cpp MarlinSerial.cpp motion_control.cpp planner.cpp qr_solve.cpp Sd2Card.cpp SdBaseFile.cpp SdFatUtil.cpp SdFile.cpp SdVolume.cpp Servo.cpp stepper.cpp temperature.cpp ultralcd.cpp vector_3.cpp watchdog.cpp
